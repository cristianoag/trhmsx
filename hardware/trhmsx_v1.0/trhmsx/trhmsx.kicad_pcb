# Repository cristianoag/trhmsx

File README.md (part):

# Introduction

>Unfortunately, there have been reports of unauthorized sales of this computer on platforms like Tindie, AliExpress and other obscure chinese marketplaces. We kindly ask you to support and reward the original creators of this project, who have generously shared their work with the retro community, rather than those engaging in unauthorized distribution. Thank you for respecting the creators' efforts and intentions.

MSX computers hold a significant place in computing history, and their legacy continues to be celebrated through innovative approaches like FPGA synthesis. Field-Programmable Gate Arrays (FPGAs) provide a unique platform for recreating the MSX architecture, offering a flexible and efficient way to re-create the hardware. 

This synthesis enables enthusiasts to experience the charm of MSX systems without relying on original, often scarce, hardware components. FPGA-based MSX simulations can faithfully replicate the distinctive features of these iconic computers, including the Z80 processor, graphics capabilities, and sound architecture. 

This modern approach not only preserves the nostalgia associated with MSX but also opens up possibilities for enhancements and customizations. FPGA synthesis ensures that the MSX spirit endures, catering to both seasoned aficionados and new generations eager to explore the roots of personal computing.

> **WARNING!** If you use this project to implement your own hardware, remember as per the license you must release the modified files under the same license. I've seen multiple projects based on files I publish on Github that were never released to the public, and I think that's a shame (and violation of the license!).

# TRHMSX - A Simple FPGA MSX2+ clone

This FPGA-based MSX2+ hardware represents a straightforward implementation, drawing inspiration from the original 1chipMSX circuit but featuring several enhancements and a new PCB design for improved functionality. Despite its advanced capabilities, the primary focus during development was on maintaining a low-cost solution.

The core of this system is the Cyclone I FPGA, accompanied by a few additional components. The PCB is a 4-layer board measuring 12x15 cm. The FPGA is a 240-pin package, which is challenging to solder manually. Instead, using an SMT oven or a hot air station is advised for optimal results. For those opting for a hot air station, employing a stencil to apply solder paste is highly recommended, significantly streamlining the assembly process.

| Kicad 3D Model | TRHMSX Computer |
|---------|---------|
|  | .jpg) |

Programming the FPGA requires the well-known OCM-PLD ESE MSX2+ core maintained by @gnogni (aka KDL), available for download [here](https://gnogni.altervista.org/) with the main development repository located at https://github.com/gnogni/ocm-pld-dev. This core ensures the proper functioning of the MSX2+ hardware, providing users with a reliable and authentic MSX experience on this FPGA-based system.

## Features

* **MSX2+ Compatibility**: Reproducing the MSX2+ architecture, ensuring compatibility with a wide range of software and games.
* **Expanded Memory Options**: Choose between 2MB or 4MB of mapped RAM, providing users with flexibility for diverse computing needs and applications.
* **9958 Video Display Processor (VDP)**: Incorporating the 9958 VDP for sharp graphics and improved visual performance, delivering an authentic MSX experience.
* **S-Video or VGA/RGB Video Output**: Supporting S-Video output for enhanced video quality or VGA/RGB output for compatibility with modern displays.
* **FM and SCC Sound Capabilities**: Featuring FM synthesis and SCC sound to reproduce the iconic audio characteristics of MSX systems, enhancing the overall gaming and multimedia experience.
* **Programmable Sound Generator (PSG)**: Including the original PSG for standard MSX audio output.
* **Keyboard Compatibility**: Supporting modern USB or PS/2 keyboards, providing users with a choice for their preferred input device.
* **MicroSD Card Support**: Integrating a microSD card slot for convenient storage and easy access to files, games, and software.
* **MSX Cartridge Slots**: Equipped with two MSX cartridge slots, allowing users to explore a vast library of MSX cartridges for an extended range of applications and games.
* **Dual Joystick Ports**: Featuring two joystick ports for multiplayer gaming and compatibility with classic MSX peripherals.
* **Wireless Network Support**: Incorporating wireless network support through the ESP8266, enabling online connectivity and expanding the possibilities for networked applications.
* **12V Cartridge Lines**: Providing dedicated 12V lines for cartridges, ensuring compatibility with a variety of peripherals and accessories.
* **Customizable Case Design**: Offering a 3D-printed base and transparent acrylic top cover, allowing users to customize the appearance of their TRHMSX system.

## Open Source

This project stands as a testament to the spirit of open source collaboration. Over the years, the original 1chipMSX circuit has inspired numerous clones, some even commercially implemented, each potentially harboring unique modifications. Regrettably, many of these adaptations were never shared with the broader community. In response, this project emerges as a fresh implementation of the original circuit, introducing enhancements and a redesigned PCB.

What sets this initiative apart is its commitment to transparency. From the project's inception, the goal was clear: to share all design files openly. This includes not only the schematics and PCB layout but also the Bill of Materials (BOM) and any other essential documentation for recreating the project.

In contrast to its predecessors, this project was conceived with a dedication to community collaboration. If you choose to utilize these resources to construct your own MSX2+ clone or find ways to enhance it, I encourage you to contribute back to the community. 

Share your experiences, document any improvements you make, and actively participate in the collective evolution of this open source initiative.

Let this project serve as a reminder of the **reciprocal nature of open source**. By using and benefiting from open source projects, it becomes a responsibility to give back, ensuring the continued growth and enrichment of the shared knowledge pool within the community.

## Bill of materials

The following table provides a comprehensive list of components required to build the latest version of the TRHMSX project. The BOM details the components, quantities, and references for each part.

I also provide links to the components on AliExpress or other sources, making it easier for you to purchase the necessary parts. 

 > **Note:** I don't have any affiliation with the sellers or guarantee the quality of the products. Please make sure to check the specifications and compatibility of the components before purchasing them.

| **Reference** | **Value** | **Description** | **Qty** | **Link** |
|---------------|-----------|-----------------|---------|----------|
| **PCB**       |           |                 |         |          |
| TRHMSX PCB    | N/A       | Custom Printed Circuit Board for the TRHMSX 1.51 | 1 | [Gerber Files](hardware/trhmsx/production/TRHMSX_-_The_simple_MSX2_clone_in_FPGA_1.51.zip) |
| **Integrated Circuits (ICs)** | | | | |
| U1            | EP1C12Q240C8N | FPGA Cyclone Family 12060 Cells 275.03MHz 130nm Technology 1.5V 240-Pin PQFP | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DEfxPNr) |
| U2            | AMS1117-1.5V | LOW DROPOUT VOLTAGE REGULATOR (1.5V) | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DEu6go1) |
| U3            | AMS1117-3.3V | LOW DROPOUT VOLTAGE REGULATOR (3.3V) | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DEu6go1) |
| U4            | NC7WZU04P6X | Dual Unbuffered Inverter | 1 | [AliExpress](https://s.click.aliexpress.com/e/_Dk6F9y9) |
| U5            | MT48LC16M16A2TG | 256Mb (4 Megabit x 16 x 4 banks) SYNCHRONOUS DRAM | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DmOI4S5) |
| U6            | M51953BFP | Voltage Detector and System Reset IC | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DnqwGxB) |
| U7            | CH559T | USB Host Micro-controller | 1 | [AliExpress](https://s.click.aliexpress.com/e/_oBU50ZV) |
| U8            | EPCS4 | 4 Mbit Serial Flash Memory (Altera Configuration) | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DD2sMq9) |
| **Resistors** |           |                 |         |          |
| RN27, RN28, RN29, RN30, RN31, RN32, RN33, RN34 | 200R | 0603X4 200R Resistor Array | 8 | [AliExpress](https://s.click.aliexpress.com/e/_DFFkTit) |
| RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10, RN11, RN13, RN14, RN15, RN16, RN19, RN20, RN21, RN22, RN23, RN36, RN37, RN38, RN39, RN40, RN41, RN42, RN43 | 100R | 0603X4 100R Resistor Array | 28 | [AliExpress](https://s.click.aliexpress.com/e/_DFFkTit) |
| RN12, RN25, RN26, RN35, RN44 | 10KR | 0603X4 10K R Resistor Array | 5 | [AliExpress](https://s.click.aliexpress.com/e/_DFFkTit) |
| RN17, RN18, RN24 | 1KR | 0603X4 1K R Resistor Array | 3 | [AliExpress](https://s.click.aliexpress.com/e/_DFFkTit) |
| R5, R12 | 1KR | 0805 1KR Resistor | 2 | [AliExpress](https://s.click.aliexpress.com/e/_DDTBoqV) |
| R13, R14 | 2.2KR | 0805 2.2KR Resistor | 2 | [AliExpress](https://s.click.aliexpress.com/e/_DDTBoqV) |
| R1, R2 | 10KR | 0805 10KR Resistor | 2 | [AliExpress](https://s.click.aliexpress.com/e/_DDTBoqV) |
| R3, R7 | 10R | 0805 10R Resistor | 2 | [AliExpress](https://s.click.aliexpress.com/e/_DDTBoqV) |
| R8, R9 | 100R | 0805 100R Resistor | 2 | [AliExpress](https://s.click.aliexpress.com/e/_DDTBoqV) |
| R10 | 22R | 0805 22R Resistor | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DDTBoqV) |
| R11 | 1MR | 0805 1MR Resistor | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DDTBoqV) |
| **Capacitors** |           |                 |         |          |
| C2, C3, C4, C6, C7, C9, C10, C11, C12, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24 | 0.1uF | 0805 100nF Ceramic Capacitor (104) | 19 | [AliExpress](https://s.click.aliexpress.com/e/_Dkt1yD7) |
| C13, C14 | 27pF | 0805 27pF Ceramic Capacitor (270) | 2 | [AliExpress](https://s.click.aliexpress.com/e/_Dkt1yD7) |
| C26, C27 | 4.7uF | 0805 4.7uF Ceramic Capacitor (475) | 2 | [AliExpress](https://s.click.aliexpress.com/e/_Dkt1yD7) |
| C33, C34 | 3.3uF | 0805 3.3uF Ceramic Capacitor (335) | 2 | [AliExpress](https://s.click.aliexpress.com/e/_Dkt1yD7) |
| C25 | 2.2uF | 0805 2.2uF Ceramic Capacitor (225) | 1 | [AliExpress](https://s.click.aliexpress.com/e/_Dkt1yD7) |
| C35 | 10uF | 0805 10uF Ceramic Capacitor (106) | 1 | [AliExpress](https://s.click.aliexpress.com/e/_Dkt1yD7) |
| C1, C5, C8, C28, C29, C30, C31, C32 | 220uF | Electrolytic Capacitor SMD 220uF 10V | 8 | [AliExpress](https://s.click.aliexpress.com/e/_DFJZp0V) |
| **LEDs and Switches** |    |                 |         |          |
| D1, D2, D3, D4, D5, D6, D7, D8, D9, D10 | Any Color | LED 0805 SMD | 10 | [AliExpress](https://s.click.aliexpress.com/e/_DEuWUBP) |
| SW1 | DIP-SW-8P-RED-90G | Slide Type DIP Sided 90° Switch Module 8Pin Position Way 2.54mm Pitch Red Toggle Switch Blue Snap Switch Dial Switch | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DdFF8Qd) |
| SW2 | BUTDIP90G6x6x12 | Momentary Tactile Tact Push Button Switch Right Angle Horizontal holder With Stent 6*6*12/mm | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DdTON3T) |
| SW3 | BUTSMD180G6x6x4 | 6x6x4.3mm SMD Tactile Push Button Switch 4 Pin | 1 | [AliExpress](https://s.click.aliexpress.com/e/_ophZTzp) |
| **Connectors** |           |                 |         |          |
| J3 | DC-005 | Female DC Power Jack supply socket 5.5X2.5mm DC-005 5.5-2.5MM Barrel | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DdYmFPj) |
| J11 | PJ-307 | 3.5mm Stereo Jack Socket Audio Jack Connector PCB 3F07 PJ-307 | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DCBm6IH) |
| J4 | MICROSDCARDHOLDER-F | MICROSD Card Holder Card Slot Card Holder Mobile Phone Memory Card Holder With Self-Elastic Long And Short Body | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DeHRUZx) |
| J7 | PS26P-B | Keyboard socket PS2 6P black socket 6-pin Connector | 1 | [AliExpress](https://s.click.aliexpress.com/e/_Dci00lF) |
| J14 | DH15-F-SHORT-B | DH15 DR15 VGA Adapter Socket 3Rows Blue Parallel Port 15 Pin D Sub 15 Way PCB 90 Degree Female Connector | 1 | [AliExpress](https://s.click.aliexpress.com/e/_DEoqLMl) |
| J13, J16 | EDGE-50P | Edge Card Connector PCB Gold Finger 50 Pin | 2 | [AliExpress](https://s.click.aliexpress.com/e/_DkkR9k9) |
| J1 | PH-254-S-F-40 | Round Hole Pin Header 2.54MM Pitch Row Female, Single Row 1x40P | 1 | [AliExpress](https://s.click.aliexpress.com/e/_oFPYktN) |

## Building

To build the project you will need the following tools and resources:

* [Quartus Prime Lite Edition](https://fpgasoftware.intel.com/?edition=lite)
* [Quartus Prime Programmer](https://fpgasoftware.intel.com/18.1/?edition=lite&platform=windows&download_manager=dlm3)
* [USB Blaster drivers](https://fpgasoftware.intel.com/18.1/?edition=lite&platform=windows&download_manager=dlm3)
* [OCM-PLD Pack](https://gnogni.altervista.org/ocm/20221127%20OCM-PLD%20Pack%20v3.9.1%20by%20KdL.7z)

To guide the building process I recommend use the interactive BOM available here [here](https://htmlpreview.github.io/?https://github.com/cristianoag/trhmsx/blob/main/hardware/trhmsx/bom/ibom.html). As you get all the required parts and PCB, use the interactive BOM to check the components and their placement.

## Programming

The programming of the TRHMSX is divided into four main parts: the FPGA, the wireless network module, the USB host micro-controller, and the microSD card.

### FPGA
The firmware for the TRHMSX is based on the first generation esemsx VHDL/Verilog code. You can download the latest packages from KDL page [here](https://gnogni.altervista.org/), or get the latest development versions directly from his GitHub [here](https://github.com/gnogni/ocm-pld-dev).

If you are downloading from the page, you will need the OCM PLD Pack file. Download it and unzip its content in a local file on your PC. If you decide to use GitHub, clone the repository to your PC.

After the unzip, go to the latest version folder and navigate to esemsx3 folder. Check the README file, you will see that you need a pretty old Quartus II version (v11.0 SP1). That is because you are using an obsolete Altera FPGA chip that cannot be programmed by recent versions of the software.

Scrolling down on KDL page you will see a link to download the right version of Quartus. Download and install it.

> **Note:** I had issues with driver certificates for the USB blaster after installing this old version of Quartus. My USB blaster stopped working as the certificates for the driver in v11 are already expired. I reinstalled the latest version of Quartus on the same PC and everything worked fine after that.

Follow the instructions on the README file to compile the appropriate files and program your FPGA. Make sure to follow the instruction to convert the programming file and incorporate the emsx_top_304k.cof file, that way you will have an MSX computer with the EPBIOS. Those steps ensure that you will have the basic BIOS together with the programming file stored on the EPCS4, that will be useful in case you have any issues with the microSD card slot.

Connect your USB Blaster cable and use the Quartus programmer tool to upload the programming file to the EPCS4 flash.

When you turn on your TRHMSX after assembling the PCB, all LEDs should lit. During programming they will flash, turn off and after boot, the TRHMSX will flash the last LED indicating it is loading the synthesis to the FPGA chip, then it will lit only the LEDs that are correspondent to the configuration on the DIP switch bank.
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
## KiCad design hardware/trhmsx_v1.0/trhmsx/trhmsx.kicad_pcb

Parts:
C1, C5, C8, C28, C29, C30, C31, C32: 220uF; CP_Elec_6.3x3
C2, C3, C4, C6, C7, C9, C10, C11, C12, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24: 0.1uF; C_0805_2012Metric
C13, C14: 27pF; C_0805_2012Metric
C25: 2.2uF; C_0805_2012Metric
C26, C27: 4.7uF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9: LED3; LED_0805_2012Metric
F1: Fuse; Fuse_1210_3225Metric
IC1: EPCS4; SO08
J1: MODULE-12V; PinSocket_1x05_P2.54mm_Vertical
J2: ESP-01; PinSocket_2x04_P2.54mm_Vertical
J3: Barrel_Jack; BarrelJack_Horizontal
J4: MICRO-SD; Conn_uSDcard
J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J6: KEYBOARD-USB; TE_6364372-2
J7: KEYBOARD-PS2; TE_5749180-1
J8: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J9: EXPANSION; PinHeader_2x25_P2.54mm_Vertical; not fitted
J10: JOY2; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
J11: AudioJack2_Ground; PJ-307
J12: RCA; CUI_RCJ-044
J13: CART2; TE_5530841-5
J14: DH15; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03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
J15: JOY1; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Hou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
J16: CART1; TE_5530841-5
R1, R2: 10K; R_0805_2012Metric
R3, R7: 10; R_0805_2012Metric
R4, R5, R6: 1K; R_0805_2012Metric
R8, R9: 100; R_0805_2012Metric
R10: 22; R_0805_2012Metric
R11: 1M; R_0805_2012Metric
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10, RN11, RN13, RN14, RN15, RN16, RN19, RN20, RN21, RN22, RN23, RN36, RN37, RN38, RN39, RN40, RN41, RN42, RN43: 100; R_Array_Convex_4x0603
RN12, RN25, RN26, RN35, RN44: 10K; R_Array_Convex_4x0603
RN17, RN18, RN24: 1K; R_Array_Convex_4x0603
RN27, RN28, RN29, RN30, RN31, RN32, RN33, RN34: 200; R_Array_Convex_4x0603
SW1: SW_DIP_x08; SW_DIP_SPSTx08_Piano_10.8x21.88mm_W7.62mm_P2.54mm
SW2: SW_Push; SW_Tactile_SPST_Angled_PTS645Vx83-2LFS
U1: EP1C12Q240C8N; QFP50P3460X3460X410-240N; MPN EP1C12Q240C8N
U2: AMS1117-1.5; SOT-223-3_TabPin2
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: NC7WZU04P6X; SOT65P210X110-6N; Manufacturer_Part_Number NC7WZU04P6X
U5: MT48LC16M16A2TG; TSOP-II-54_22.2x10.16mm_P0.8mm
U6: M51953BFP; SO08
Y1: 21.47727 MHz; Crystal_HC49-U_Vertical

Connections (part):
+1V5: C4.1, C5.1, C20.2, C21.2, C22.2, C23.2, R3.2, R7.2, U1.72 (VCCINT), U1.81 (VCCINT_5), U1.90 (VCCINT), U1.97 (VCCINT_2), U1.103 (VCCINT_4), U1.110 (VCCINT_3), U1.191 (VCCINT_2), U1.198 (VCCINT_3), U1.204 (VCCINT_4), U1.211 (VCCINT_5), U1.220 (VCCINT_6), U1.229 (VCCINT), U2.2 (VO)
+3.3V: C7.1, C8.1, C9.1, C11.1, C12.2, C15.1, C16.2, C17.2, C18.2, C19.2, IC1.3 (VCC@3), IC1.7 (VCC@7), IC1.8 (VCC@8), J2.4, J2.8, J4.4 (VDD), J8.4, R1.1, R2.1, R4.1, R6.1, RN12.1 (R1.1), RN12.2 (R2.1), RN12.3 (R3.1), RN24.1 (R1.1), RN24.2 (R2.1), RN24.3 (R3.1), RN24.4 (R4.1), RN25.6 (R3.2), RN25.7 (R2.2), RN25.8 (R1.2), RN26.5 (R4.2), RN26.6 (R3.2), RN26.7 (R2.2), RN26.8 (R1.2), RN35.6 (R3.2), RN35.7 (R2.2), RN35.8 (R1.2), RN44.5 (R4.2), RN44.6 (R3.2), RN44.7 (R2.2), RN44.8 (R1.2), U1.9 (VCCIO1), U1.22 (VCCIO1_2), U1.51 (VCCIO1_3), U1.70 (VCCIO4), U1.92 (VCCIO4_2), U1.112 (VCCIO4), U1.130 (VCCIO3_2), U1.148 (TMS), U1.155 (TDI), U1.157 (VCCIO3), U1.172 (VCCIO3), U1.189 (VCCIO2), U1.209 (VCCIO2_2), U1.231 (VCCIO2_3), U3.2 (VO), U4.5 (VCC), U5.1 (VDD), U5.3 (VDDQ), U5.9 (VDDQ), U5.14 (VDD), U5.27 (VDD), U5.43 (VDDQ), U5.49 (VDDQ)
+5V: C1.1, C2.1, C6.1, C24.1, J1.5, J5.2, J6.1 (VBUS), J7.4, J9.45, J9.47, J10.5, J13.45, J13.47, J14.9, J15.5, J16.45, J16.47, U2.3 (VI), U3.3 (VI), U6.7 (VCC)
+12V: J1.3, J9.48, J13.48, J16.48
-12V: J1.1, J9.50, J13.50, J16.50
/A0: J9.28, J13.28, J16.28, RN2.2 (R2.1)
/A1: J9.27, J13.27, J16.27, RN2.1 (R1.1)
/A2: J9.30, J13.30, J16.30, RN2.4 (R4.1)
/A3: J9.29, J13.29, J16.29, RN2.3 (R3.1)
/A4: J9.32, J13.32, J16.32, RN3.2 (R2.1)
/A5: J9.31, J13.31, J16.31, RN3.1 (R1.1)
/A6: J9.22, J13.22, J16.22, RN6.4 (R4.1)
/A7: J9.21, J13.21, J16.21, RN6.3 (R3.1)
/A8: J9.24, J13.24, J16.24, RN1.2 (R2.1)
/A9: J9.17, J13.17, J16.17, RN11.1 (R1.1)
/A10: J9.20, J13.20, J16.20, RN11.4 (R4.1)
/A11: J9.19, J13.19, J16.19, RN11.3 (R3.1)
/A12: J9.23, J13.23, J16.23, RN1.1 (R1.1)
/A13: J9.26, J13.26, J16.26, RN1.4 (R4.1)
/A14: J9.25, J13.25, J16.25, RN1.3 (R3.1)
/A15: J9.18, J13.18, J16.18, RN11.2 (R2.1)
/AS_CK: IC1.6 (DCLK), J8.1, U1.36 (DCLK)
/AS_CS: IC1.1 (NCS), J8.8, U1.24 (IO_22)
/AS_DI: IC1.2 (DATA), J8.7, U1.25 (DATA0)
/AS_DO: IC1.5 (ASDI), J8.9, U1.37 (IO_23)
/BDIR: J9.10, J13.10, J16.10, RN9.3 (R3.1)
/CLK21M: R9.2, U1.28 (CLK0)
/CLOCK: J9.42, J13.42, J16.42, RN6.2 (R2.1)
/CS1: J9.1, J13.1, J16.1, RN7.2 (R2.1)
/CS2: J9.2, J13.2, J16.2, RN7.3 (R3.1)
/CS12: J9.3, J13.3, J16.3, RN7.4 (R4.1)
/C_CE: J8.6, RN12.5 (R4.2), U1.33 (NCE)
/C_CONF: J8.5, RN12.7 (R2.2), U1.26 (NCONFIG)
/C_DONE: J8.3, RN12.8 (R1.2), U1.145 (CONF_DONE)
/C_STAT: RN12.6 (R3.2), U1.146 (NSTATUS)
/D0: J9.34, J13.34, J16.34, RN3.4 (R4.1)
/D1: J9.33, J13.33, J16.33, RN3.3 (R3.1)
/D2: J9.36, J13.36, J16.36, RN4.2 (R2.1)
/D3: J9.35, J13.35, J16.35, RN4.1 (R1.1)
/D4: J9.38, J13.38, J16.38, RN4.4 (R4.1)
/D5: J9.37, J13.37, J16.37, RN4.3 (R3.1)
/D6: J9.40, J13.40, J16.40, RN5.2 (R2.1)
/D7: J9.39, J13.39, J16.39, RN5.1 (R1.1)
/DIP1: RN19.1 (R1.1), SW1.16
/DIP2: RN19.2 (R2.1), SW1.15
/DIP3: RN19.3 (R3.1), SW1.14
/DIP4: RN19.4 (R4.1), SW1.13
/DIP5: RN20.1 (R1.1), SW1.12
/DIP6: RN20.2 (R2.1), SW1.11
/DIP7: RN20.3 (R3.1), SW1.10
/DIP8: RN20.4 (R4.1), SW1.9
/EXTCLK: R8.2, U1.29 (CLK1)
/HSYNC: J14.13, RN23.3 (R3.1)
/INT: J9.8, J13.8, J16.8, RN9.1 (R1.1)
/IO0: J15.1, RN13.1 (R1.1), RN44.1 (R1.1)
/IO1: J15.6, RN13.2 (R2.1), RN44.2 (R2.1)
/IO2: J15.2, RN13.3 (R3.1), RN44.3 (R3.1)
/IO3: J15.7, RN13.4 (R4.1), RN44.4 (R4.1)
/IO4: J15.3, RN14.1 (R1.1), RN35.1 (R1.1)
/IO5: J15.8, RN14.2 (R2.1), RN35.2 (R2.1)
/IO6: J15.4, RN14.3 (R3.1), RN35.3 (R3.1)
/IO7: J10.1, RN14.4 (R4.1), RN26.1 (R1.1)
/IO8: J10.6, RN15.1 (R1.1), RN26.2 (R2.1)
/IO9: J10.2, RN15.2 (R2.1), RN26.3 (R3.1)
/IO10: J10.7, RN15.3 (R3.1), RN26.4 (R4.1)
/IO11: J10.3, RN15.4 (R4.1), RN25.1 (R1.1)
/IO12: J10.8, RN16.1 (R1.1), RN25.2 (R2.1)
/IO13: J10.4, RN16.2 (R2.1), RN25.3 (R3.1)
/IORQ: J9.11, J13.11, J16.11, RN9.4 (R4.1)
/KCLK: J6.3 (D+), J7.5, R4.2, RN22.4 (R4.1)
/KDAT: J6.2 (D-), J7.1, R6.2, RN22.3 (R3.1)
/LED1: D1.2 (A), RN17.1 (R1.1)
/LED2: D2.2 (A), RN17.2 (R2.1)
/LED3: D3.2 (A), RN17.3 (R3.1)
/LED4: D4.2 (A), RN17.4 (R4.1)
/LED5: D5.2 (A), RN18.1 (R1.1)
/LED6: D6.2 (A), RN18.2 (R2.1)
/LED7: D7.2 (A), RN18.3 (R3.1)
/LED8: D8.2 (A), RN18.4 (R4.1)
/M1: J9.9, J13.9, J16.9, RN9.2 (R2.1)
/MA0: U1.203 (IO_36), U5.23 (A0)
/MA1: U1.206 (IO_37), U5.24 (A1)
/MA2: U1.207 (IO_38), U5.25 (A2)
/MA3: U1.208 (IO_39), U5.26 (A3)
/MA4: U1.235 (IO_56), U5.29 (A4)
/MA5: U1.234 (IO_55), U5.30 (A5)
/MA6: U1.233 (IO_54), U5.31 (A6)
/MA7: U1.228 (IO_53), U5.32 (A7)
/MA8: U1.227 (IO_52), U5.33 (A8)
/MA9: U1.226 (IO_51), U5.34 (A9)
/MA10: U1.202 (IO_35), U5.22 (A10)
/MA11: U1.225 (IO_50), U5.35 (A11)
/MA12: U1.224 (IO_49), U5.36 (A12)
/MBA0: U1.200 (IO_33), U5.20 (BA0)
/MBA1: U1.201 (IO_34), U5.21 (BA1)
/MCAS: U1.195 (IO_30), U5.17 (~CAS)
/MCKE: U1.39 (IO_25), U5.37 (CKE)
/MCLK: R10.1, U5.38 (CLK)
/MCS: U1.197 (IO_32), U5.19 (~CS)
/MD0: U1.181 (IO_20), U5.2 (DQ0)
/MD1: U1.182 (IO_21), U5.4 (DQ1)
/MD2: U1.183 (IO_22), U5.5 (DQ2)
/MD3: U1.184 (IO_23), U5.7 (DQ3)
/MD4: U1.185 (IO_24), U5.8 (DQ4)
/MD5: U1.186 (IO_25), U5.10 (DQ5)
/MD6: U1.187 (IO_26), U5.11 (DQ6)
/MD7: U1.188 (IO_27), U5.13 (DQ7)
/MD8: U1.222 (IO_47), U5.42 (DQ8)
/MD9: U1.219 (IO_46), U5.44 (DQ9)
/MD10: U1.218 (IO_45), U5.45 (DQ10)
/MD11: U1.217 (IO_44), U5.47 (DQ11)
/MD12: U1.216 (IO_43), U5.48 (DQ12)
/MD13: U1.215 (IO_42), U5.50 (DQ13)
/MD14: U1.214 (IO_41), U5.51 (DQ14)
/MD15: U1.213 (IO_40), U5.53 (DQ15)
/MERQ: J9.12, J13.12, J16.12, RN10.1 (R1.1)
/MLDQ: U1.193 (IO_28), U5.15 (DQML)
/MRAS: U1.196 (IO_31), U5.18 (~RAS)
/MUDQ: U1.223 (IO_48), U5.39 (DQMH)
/MWE: U1.194 (IO_29), U5.16 (~WE)
/PWRLED: R5.1, U1.240 (IO)
/RD: J9.14, J13.14, J16.14, RN10.3 (R3.1)
/RESET: J9.15, J13.15, J16.15, RN6.1 (R1.1), RN24.8 (R1.2), U6.6 (OUT)
/RFSH: J9.6, J13.6, J16.6, RN8.3 (R3.1), RN24.5 (R4.2)
/RSV5: J9.5, J13.5, J16.5, RN8.2 (R2.1), RN24.7 (R2.2)
/RSV16: J9.16, J13.16, J16.16, RN10.4 (R4.1), RN24.6 (R3.2)
/SCLK: J14.12, RN23.4 (R4.1)
/SDAT: J14.15, RN23.1 (R1.1)
/SD_CK: J4.5 (CLK), R2.2, RN21.3 (R3.1)
/SD_CM: J4.3 (CMD), R1.2, RN21.4 (R4.1)
/SD_D0: J4.7 (DAT0), RN21.2 (R2.1)
/SD_D1: J4.8 (DAT1), RN21.1 (R1.1)
/SD_D2: J4.1 (DAT2), RN22.2 (R2.1)
/SD_D3: J4.2 (DAT3/CD), RN22.1 (R1.1)
/SL0: RN29.4 (R4.1), U1.105 (IO_17)
/SL1: RN29.3 (R3.1), U1.106 (IO_18)
/SL2: RN29.2 (R2.1), U1.107 (IO_19)
/SL3: RN29.1 (R1.1), U1.108 (IO_20)
/SL4: RN28.4 (R4.1), U1.113 (IO_21)
/SL5: RN28.3 (R3.1), U1.114 (IO_22)
/SLTSL1: J9.4, J16.4, RN8.1 (R1.1)
/SLTSL2: J13.4, RN7.1 (R1.1)
/SOUND_L: C26.2, C27.2, C29.2, J9.49, J11.T
/SOUND_R: C28.2, J11.S
/SR0: RN28.2 (R2.1), U1.115 (IO_23)
/SR1: RN28.1 (R1.1), U1.116 (IO_24)
/SR2: RN27.4 (R4.1), U1.117 (IO_25)
/SR3: RN27.3 (R3.1), U1.118 (IO_26)
/SR4: RN27.2 (R2.1), U1.119 (IO_27)
/SR5: RN27.1 (R1.1), U1.120 (IO_28)
/SW1: J9.44, J13.44, J16.44, RN5.3 (R3.1)
/SW2: J9.46, J13.46, J16.46, RN5.4 (R4.1)
/USBN1: J2.2, U1.236 (IO_57)
/USBP1: J2.7, U1.237 (IO_58)
/VB0: RN31.2 (R2.1), U1.77 (IO_56)
/VB1: RN31.1 (R1.1), U1.78 (IO_57)
/VB2: RN30.4 (R4.1), U1.79 (IO)
/VB3: RN30.3 (R3.1), U1.82 (IO_2)
/VB4: RN30.2 (R2.1), U1.83 (IO_3)
/VB5: RN30.1 (R1.1), U1.84 (IO_4)
/VB_CV: C30.2, J12.1 (In), J14.3
/VG0: RN32.4 (R4.1), U1.85 (IO_5)
/VG1: RN32.3 (R3.1), U1.86 (IO_6)
/VG2: RN32.2 (R2.1), U1.87 (IO_7)
/VG3: RN32.1 (R1.1), U1.88 (IO_8)
/VG4: RN31.4 (R4.1), U1.93 (IO_9)
/VG5: RN31.3 (R3.1), U1.94 (IO_10)
/VG_SY: C31.2, J14.2
/VR0: RN34.2 (R2.1), U1.95 (IO_11)
/VR1: RN34.1 (R1.1), U1.98 (IO_12)
/VR2: RN33.4 (R4.1), U1.99 (IO_13)
/VR3: RN33.3 (R3.1), U1.100 (IO_14)
/VR4: RN33.2 (R2.1), U1.101 (IO_15)
/VR5: RN33.1 (R1.1), U1.104 (IO_16)
/VR_SC: C32.2, J14.1
/VSYNC: J14.14, RN23.2 (R2.1)
/WAIT: J9.7, J13.7, J16.7, RN8.4 (R4.1)
/WR: J9.13, J13.13, J16.13, RN10.2 (R2.1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.1, C13.2, C14.2, C15.2, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.2, C25.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), IC1.4 (GND), J1.2, J1.4, J2.1, J3.2, J4.6 (VSS), J6.4 (GND), J6.5 (Shield), J7.3, J8.2, J8.10, J9.41, J9.43, J10.9, J11.G, J12.2 (Ext), J13.41, J13.43, J14.5, J14.6, J14.7, J14.8, J14.10, J15.9, J16.41, J16.43, RN12.4 (R4.1), RN37.7 (R2.2), RN38.5 (R4.2), RN40.7 (R2.2), RN41.5 (R4.2), RN43.7 (R2.2), SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, SW2.1, U1.10 (GND_3), U1.30 (GNDA_PLL1), U1.31 (GNDG_PLL1), U1.34 (MSEL0), U1.35 (MSEL1), U1.40 (GND_4)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
unnamed: D9.2 (A), R5.2
unnamed: F1.1, J3.1
unnamed: F1.2, J5.1
unnamed: C26.1, J13.49
unnamed: C27.1, J16.49
unnamed: RN1.8 (R1.2), U1.159 (IO_52)
unnamed: RN1.7 (R2.2), U1.160 (IO)
unnamed: RN1.6 (R3.2), U1.161 (IO_2)
unnamed: RN1.5 (R4.2), U1.162 (IO_3)
unnamed: RN2.8 (R1.2), U1.163 (IO_4)
unnamed: RN2.7 (R2.2), U1.164 (IO_5)
unnamed: RN2.6 (R3.2), U1.165 (IO_6)
unnamed: RN2.5 (R4.2), U1.166 (IO_7)
unnamed: RN3.8 (R1.2), U1.167 (IO_8)
unnamed: RN3.7 (R2.2), U1.168 (IO_9)
unnamed: RN3.6 (R3.2), U1.169 (IO_10)
unnamed: RN3.5 (R4.2), U1.170 (IO_11)
unnamed: RN4.8 (R1.2), U1.173 (IO_12)
unnamed: RN4.7 (R2.2), U1.174 (IO_13)
unnamed: RN4.6 (R3.2), U1.175 (IO_14)
unnamed: RN4.5 (R4.2), U1.176 (IO_15)
unnamed: RN5.8 (R1.2), U1.177 (IO_16)
unnamed: RN5.7 (R2.2), U1.178 (IO_17)
unnamed: RN5.6 (R3.2), U1.179 (IO_18)
unnamed: RN5.5 (R4.2), U1.180 (IO_19)
unnamed: RN6.8 (R1.2), U1.153 (CLK2)
unnamed: RN6.7 (R2.2), U1.144 (IO_49), U1.152 (CLK3)
unnamed: RN6.6 (R3.2), U1.156 (IO_50)
unnamed: RN6.5 (R4.2), U1.158 (IO_51)
unnamed: RN7.8 (R1.2), U1.121 (IO_29)
unnamed: RN7.7 (R2.2), U1.122 (IO_30)
unnamed: RN7.6 (R3.2), U1.123 (IO_31)
unnamed: RN7.5 (R4.2), U1.124 (IO_32)
unnamed: RN8.8 (R1.2), U1.125 (IO_33)
unnamed: RN8.7 (R2.2), U1.126 (IO_34)
unnamed: RN8.6 (R3.2), U1.127 (IO_35)
unnamed: RN8.5 (R4.2), U1.128 (IO_36)
unnamed: RN9.8 (R1.2), U1.131 (IO_37)
unnamed: RN9.7 (R2.2), U1.132 (IO_38)
unnamed: RN9.6 (R3.2), U1.133 (IO_39)
unnamed: RN9.5 (R4.2), U1.134 (IO_40)
unnamed: RN10.8 (R1.2), U1.135 (IO_41)
unnamed: RN10.7 (R2.2), U1.136 (IO_42)
unnamed: RN10.6 (R3.2), U1.137 (IO_43)
unnamed: RN10.5 (R4.2), U1.138 (IO_44)
unnamed: RN11.8 (R1.2), U1.139 (IO_45)
unnamed: RN11.7 (R2.2), U1.140 (IO_46)
unnamed: RN11.6 (R3.2), U1.141 (IO_47)
unnamed: RN11.5 (R4.2), U1.143 (IO_48)
unnamed: RN13.8 (R1.2), U1.1 (IO_2)
unnamed: RN13.7 (R2.2), U1.2 (IO_3)
unnamed: RN13.6 (R3.2), U1.3 (IO_4)
unnamed: RN13.5 (R4.2), U1.4 (IO_5)
unnamed: RN14.8 (R1.2), U1.5 (IO_6)
unnamed: RN14.7 (R2.2), U1.6 (IO_7)
unnamed: RN14.6 (R3.2), U1.7 (IO_8)
unnamed: RN14.5 (R4.2), U1.8 (IO_9)
unnamed: RN15.8 (R1.2), U1.11 (IO_10)
unnamed: RN15.7 (R2.2), U1.12 (IO_11)
unnamed: RN15.6 (R3.2), U1.13 (IO_12)
unnamed: RN15.5 (R4.2), U1.14 (IO_13)
unnamed: RN16.8 (R1.2), U1.15 (IO_14)
unnamed: RN16.7 (R2.2), U1.16 (IO_15)
unnamed: RN17.8 (R1.2), U1.43 (IO_28)
unnamed: RN17.7 (R2.2), U1.44 (IO_29)
unnamed: RN17.6 (R3.2), U1.45 (IO_30)
unnamed: RN17.5 (R4.2), U1.46 (IO_31)
unnamed: RN18.8 (R1.2), U1.47 (IO_32)
unnamed: RN18.7 (R2.2), U1.48 (IO_33)
unnamed: RN18.6 (R3.2), U1.49 (IO_34)
unnamed: RN18.5 (R4.2), U1.50 (IO_35)
unnamed: RN19.8 (R1.2), U1.53 (IO_36)
unnamed: RN19.7 (R2.2), U1.54 (IO_37)
unnamed: RN19.6 (R3.2), U1.55 (IO_38)
unnamed: RN19.5 (R4.2), U1.56 (IO_39)
unnamed: RN20.8 (R1.2), U1.57 (IO_40)
unnamed: RN20.7 (R2.2), U1.58 (IO_41)
unnamed: RN20.6 (R3.2), U1.59 (IO_42)
unnamed: RN20.5 (R4.2), U1.60 (IO_43)
unnamed: RN21.8 (R1.2), U1.61 (IO_44)
unnamed: RN21.7 (R2.2), U1.62 (IO_45)
unnamed: RN21.6 (R3.2), U1.63 (IO_46)
unnamed: RN21.5 (R4.2), U1.64 (IO_47)
unnamed: RN22.8 (R1.2), U1.65 (IO_48)
unnamed: RN22.7 (R2.2), U1.66 (IO_49)
unnamed: RN22.6 (R3.2), U1.67 (IO_50)
unnamed: RN22.5 (R4.2), U1.68 (IO_51)
unnamed: RN23.8 (R1.2), U1.73 (IO_52)
unnamed: RN23.7 (R2.2), U1.74 (IO_53)
unnamed: RN23.6 (R3.2), U1.75 (IO_54)
unnamed: RN23.5 (R4.2), U1.76 (IO_55)
unnamed: C28.1, RN27.8 (R1.2), RN36.1 (R1.1)
unnamed: RN27.7 (R2.2), RN36.2 (R2.1), RN36.8 (R1.2)
unnamed: RN27.6 (R3.2), RN36.3 (R3.1), RN36.7 (R2.2)
unnamed: RN27.5 (R4.2), RN36.4 (R4.1), RN36.6 (R3.2)
unnamed: RN28.8 (R1.2), RN36.5 (R4.2), RN37.1 (R1.1)
unnamed: RN28.7 (R2.2), RN37.2 (R2.1), RN37.8 (R1.2)
unnamed: C29.1, RN28.6 (R3.2), RN37.3 (R3.1)
unnamed: RN28.5 (R4.2), RN37.4 (R4.1), RN37.6 (R3.2)
unnamed: RN29.8 (R1.2), RN37.5 (R4.2), RN38.1 (R1.1)
unnamed: RN29.7 (R2.2), RN38.2 (R2.1), RN38.8 (R1.2)
unnamed: RN29.6 (R3.2), RN38.3 (R3.1), RN38.7 (R2.2)
unnamed: RN29.5 (R4.2), RN38.4 (R4.1), RN38.6 (R3.2)
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
Board: 2 copper layers, 122 parts (40 on the bottom side), 307 nets, no tracks yet.

File hardware/trhmsx_v1.0/trhmsx/production/TRHMSX_-_The_simple_MSX2_clone_in_FPGA_1.0_2023-12-28_19-38-42/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
AUDIO,PJ-307,1,AudioJack2_Ground,
"C1, C28, C29, C30, C31, C32, C5, C8",CP_Elec_6.3x3,8,220uF,
"C10, C11, C12, C15, C16, C17, C18, C19, C2, C20, C21, C22, C23, C24, C3, C4, C6, C7, C9",0805,19,0.1uF,
"C13, C14",0805,2,27pF,
C25,0805,1,2.2uF,
"C26, C27",0805,2,4.7uF,
COMPOSITE,CUI_RCJ-044,1,RCA,
CONFIG,SW_DIP_SPSTx08_Piano_10.8x21.88mm_W7.62mm_P2.54mm,1,SW_DIP_x08,
"D1, D2, D3, D4, D5, D6, D7, D8, D9",0805,9,LED3,
F1,1210,1,Fuse,
IC1,SO08,1,EPCS4,
J1,PinSocket_1x05_P2.54mm_Vertical,1,MODULE-12V,
J13,TE_5530841-5,1,CART2,
J16,TE_5530841-5,1,CART1,
J2,PinSocket_2x04_P2.54mm_Vertical,1,ESP-01,
J5,PinHeader_1x02_P2.54mm_Vertical,1,Conn_01x02,
JOYSTICK1,DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Housed_MountingHolesOffset7.48mm,1,JOY1,
JOYSTICK2,DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Housed_MountingHolesOffset7.48mm,1,JOY2,
JTAG,PinHeader_2x05_P2.54mm_Vertical,1,Conn_02x05_Odd_Even,
LOGO_MSX,LOGO_MSX,1,,
MICROSD,Conn_uSDcard,1,MICRO-SD,
POWER,BarrelJack_Horizontal,1,Barrel_Jack,
PS/2 KEYBOARD,TE_5749180-1,1,KEYBOARD-PS2,
"R1, R2",0805,2,10K,
R10,0805,1,22,
R11,0805,1,1M,
"R3, R7",0805,2,10,
"R4, R5, R6",0805,3,1K,
"R8, R9",0805,2,100,
RESET,SW_Tactile_SPST_Angled_PTS645Vx83-2LFS,1,SW_Push,
RGB/VGA,DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03mm_Housed_MountingHolesOffset4.94mm,1,DH15,
"RN1, RN10, RN11, RN13, RN14, RN15, RN16, RN19, RN2, RN20, RN21, RN22, RN23, RN3, RN36, RN37, RN38, RN39, RN4, RN40, RN41, RN42, RN43, RN5, RN6, RN7, RN8, RN9",R_Array_Convex_4x0603,28,100,
"RN12, RN25, RN26, RN35, RN44",R_Array_Convex_4x0603,5,10K,
"RN17, RN18, RN24",R_Array_Convex_4x0603,3,1K,
"RN27, RN28, RN29, RN30, RN31, RN32, RN33, RN34",R_Array_Convex_4x0603,8,200,
U1,QFP50P3460X3460X410-240N,1,EP1C12Q240C8N,EP1C12Q240C8N
U2,SOT-223-3_TabPin2,1,AMS1117-1.5,
U3,SOT-223-3_TabPin2,1,AMS1117-3.3,
U4,SOT65P210X110-6N,1,NC7WZU04P6X,
U5,TSOP-II-54_22.2x10.16mm_P0.8mm,1,MT48LC16M16A2TG,
U6,SO08,1,M51953BFP,
USB KEYBOARD,TE_6364372-2,1,KEYBOARD-USB,
Y1,Crystal_HC49-U_Vertical,1,21.47727 MHz,

## Commit log

2023-09-25 Sunday work
2023-09-27 working on the base circuit
2023-09-27 USB-PS2
2023-09-27 PS/2 and USB for simple keyboards
2023-10-02 Joysticks, memory and active serial config
2023-10-02 Readme
2023-10-09 finishing FPGA wiring
2023-10-09 USB wiring
2023-10-09 wifi usb dongle
2023-10-30 First version of the PCB
2023-11-20 Initial placement
2023-11-26 routing phase 1
2023-11-26 pcb image
2023-12-29 Gerbers and small adjustments
2024-03-10 1.2 update
2024-03-10 license fix
2024-03-10 README Update
2024-03-14 Update images and README
2024-03-22 Fixes
2024-03-24 pin header for enabling the ESP-01
2024-04-25 minor changes
2024-04-25 gitignore
2024-04-25 interactive BOM
2024-04-25 removing case old versions
2024-04-28 microSD card instructions
2024-04-28 microSD instructions
2024-04-29 Quick Guides
2024-05-06 Covers for the case holes and top cover in STL
2024-05-06 Transucent Cover
2024-05-17 User guides
2024-05-17 Fixing links on README file
2024-05-17 Fixing some links
2024-06-04 1.4 release. minor fixes.
2024-11-01 fixed the 3d printed translucent cover
2024-11-10 v1.5 wip - general USB keyboards and s-video
2024-11-15 Case update
2024-12-18 hidman-micro firmware
2024-12-31 CH559T firmware and WCH ISP Tool
2024-12-31 .gitignore
2024-12-31 Recompiling the firmware to support USB keyboards, fix for SVIDEO. 1.51 release.
2024-12-31 1.51 gerbers and BOM
2025-01-01 Update to the 1.5 manual. Organizing the content.
2025-01-01 readme.md updates
2025-01-01 v1.51 and content organization
2025-01-01 README.MD update

Notices in the files:
README.md:
License:
This work is licensed under a [Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International License](http://creativecommons.org/licenses/by-nc-sa/4.0/).
If you remix, transform, or build upon the material, you must distribute your contributions under the same license as the original.
You may not use the material for commercial purposes.
You must give appropriate credit, provide a link to the license, and indicate if changes were made. You may do so in any reasonable manner, but not in any way that suggests the licensor endorses you or you
